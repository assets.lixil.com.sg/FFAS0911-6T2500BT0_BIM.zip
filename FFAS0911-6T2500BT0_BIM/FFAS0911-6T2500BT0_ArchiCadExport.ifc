Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T09:39:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190731_1515(x64) - Exporter 20.1.1.1 - Alternate UI 20.1.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 09:39:44 2023 * Host: L0310_2208R689 * Database: C:\Users\phitssat\AppData\Local\Temp\bb6f013f-03b1-4947-96b7-5025e4dcd981\fb022244-9626-498d-8b1f-8ea0ffb65b67\ifc * Database version: 5507 * Database creation date: Thu Mar 30 09:39:43 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 09:39:43 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 09:39:43 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAS0911-6T2500BT0_REVIT:Milano Exposed B&S Mixer W/ Shower Kis, FFAS0911-6T2500BT0_REVIT:Milano Exposed B&S Mixer W/ Shower Kis:348040
In: Level 1
Material: White, Chrome
Pset_DistributionFlowElementCommon - Reference: Milano Exposed B&S Mixer W/ Shower Kis; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
